<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Feb 9 23:40:57 2026</timestamp>
			<uuid>{107ede82-e0b0-4193-b6d4-c8b2ed9a5887}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/home/jhsu2022/eec216/EEC216_jhsu2022/dp1MMnor5CMOSH_tb_power/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/home/jhsu2022/eec216/EEC216_jhsu2022/dp1MMnor5CMOSH_tb_power/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/home/jhsu2022/simulation/EEC216_jhsu2022/dp1MMnor5CMOSH_tb_power/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/EEC216_jhsu2022/dp1MMnor5CMOSH_tb_power/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
		</historyentry>
	</history>
</setupdb>
